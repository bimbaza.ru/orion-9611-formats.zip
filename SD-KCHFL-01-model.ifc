Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-KCHFL-01-model.ifc
Time: 2026-09-03T23:25:52+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-KCHFL-01 Качалка на пружине «Барашек» · исполнение 2 Эко
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-KCHFL-01; ModelReference: Качалка на пружине «Барашек» · исполнение 2 Эко; ProductionYear: 2026
